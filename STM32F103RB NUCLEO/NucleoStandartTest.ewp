# IAR project NucleoStandartTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ; ..\; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc\; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport\; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers\02-Drivers\2.1-inc; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\src; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers\02-Drivers\2.2-src; E:\Yedekler\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers\02-Drivers; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NucleoStandartTest.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group STD_Lib
    E:/Yedekler/01-ARGE/01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    E:/Yedekler/01-ARGE/01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    E:/Yedekler/01-ARGE/01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STD_Lib/src
    E:/Yedekler/01-ARGE/01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
